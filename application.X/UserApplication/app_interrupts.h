/*###############################################################################################################################
 # 文件名称 ： u80711R01_INTERRUPTS_H                                                                                           #
 # 公司名称 :  TOTEX Technology, Inc.                                                                                           #
 # 芯片型号 ： PIC24FJ128GA302                                                                                                  #
 # 编译工具 :  ccs compiler v5.118                                                                                              #
 # 作    者 :  BenZhang                                                                                                         #
 # 编写日期 :  2025/11/10                                                                                                       #
 # 版    本 :  v1.00                                                                                                            #
 ##############################################################################################################################*/
#ifndef APP_INTERRUPTS_H
#define	APP_INTERRUPTS_H
/*###############################################################################################################################
# 包含文件                                                                                                                      #
###############################################################################################################################*/
#include "app_config.h"
#include "apps_drive.h"
#include "app_tmag3001.h"
#include "app_bq76952.h"
/*###############################################################################################################################
# 声明开始                                                                                                                      #
###############################################################################################################################*/
#ifdef	__cplusplusextern "C" {
#endif

#define b_CHGING    FG.b.CHGING
/*###############################################################################################################################
# 函数声明                                                                                                                      #
###############################################################################################################################*/
void timer1_interrupts(void);
void timer2_interrupts(void);
void timer3_interrupts(void);
void externa1_interrupt(void);
void externa2_interrupt(void);
void externa3_interrupt(void);
void externa4_interrupt(void);
void uart_interrupt(void);
void commands_process(void);
/*###############################################################################################################################
# 函数名  :  void Timer1_interrupts(void)                                                                                       #
# 功  能  :  定时器1中断(10毫秒中断一次)                                                                                        #
# 参  数  :  NONE                                                                                                               #
# 说  明  :  NONE                                                                                                               #                            
###############################################################################################################################*/
#INT_TIMER1
void timer1_interrupts(void) {
    clear_interrupt(INT_TIMER1);								//##(0)清除中断标志
    regs.time10ms++;											//##(0)10毫秒计数器递增
    regs.keyState = Keyboard_Button_Process();					//##(0)扫描按键 
    regs.keyCurrState = regs.keyState;							//##(0)同时更新到另一个寄存器中以便判断是显示容量按钮还是开机按钮 
    if(regs.flags.NoComTmrEn==false) return;					//##(0)停止无通讯超时计时则退出【在"EXO"模式下有通讯无应答超时计时】
    regs.NoCommTimeout++;
    if(regs.NoCommTimeout>1000 && regs.LastIDType==IDEXO)		//##(0)如果连接上"EXO"并且无应答时间超过10秒则设置通讯故障 500
		regs.FaultLive.COM = TRUE;	
    if(regs.flags.IDType==IDCHG && regs.flags.ChgProc) return;	//##(0如果接入的是充电器并且正在充电则没有无应答超时强行进入睡眠模式【不做20秒超时判断】
//    if(regs.NoCommTimeout>2000 && !regs.flags.MsgPrint)				//##(0)做无应答20秒强行进入睡眠模式(前提是没有使能自动发送信息)) 
//    	regs.flags.RunMode = MODE_EnterSLEEP;
  //  regs.flags.NoWdtWakeup |= 1;
}
/*###############################################################################################################################
# 函数名  :  void Timer2_interrupts(void)                                                                                       #
# 功  能  :  定时器1中断(1000毫秒中断一次),充电超时使用                                                                         #
# 参  数  :  NONE                                                                                                               #
# 说  明  :  NONE                                                                                                               #                            
###############################################################################################################################*/
#INT_TIMER2
void timer2_interrupts(void) {
    clear_interrupt(INT_TIMER2);            //##(0)清除中断标志
    regs.system1000ms++;                    //##(0)1000毫秒计数器递增 
    regs.resttimer++;                       //##(0)休息时间递增
    regs.flags.NoWdtWakeup |= 1;
}
/*###############################################################################################################################
# 函数名  :  void Timer2_interrupts(void)                                                                                       #
# 功  能  :  定时器3中断(5毫秒中断一次),动画刷新使用                                                                            #
# 参  数  :  NONE                                                                                                               #
# 说  明  :  NONE                                                                                                               #                            
###############################################################################################################################*/
#INT_TIMER3 Level = 5                       //##(0)次高优先级
void timer3_interrupts(void) {
    clear_interrupt(INT_TIMER3);            //##(0)清除中断标志
    regs.system5ms++;
    AnimationDisplay_Process(&Frame);       //##(0)动画显示进程
}
/*###############################################################################################################################
# 函数名 :  void external_interrupt1(void)                                                                                      #
# 功  能 :  外部中断[1]函数                                                                                                     #
# 参  数 :  NONE                                                                                                                #
# 说  明 :  设定中断表示[按钮中断]                                                                                              #
###############################################################################################################################*/
#INT_EXT0
void externa0_interrupt(void) {
    clear_interrupt(INT_EXT0);          //##(0)中断标志清零
    regs.flags.sysint = true;           //##(0)SYS_INT引脚唤醒标志 = 1
    regs.flags.NoWdtWakeup |= 1;        //##(0)设置不是看门狗唤醒
} 
/*###############################################################################################################################
# 函数名 :  void external_interrupt1(void)                                                                                      #
# 功  能 :  外部中断[1]函数                                                                                                     #
# 参  数 :  NONE                                                                                                                #
# 说  明 :  设定中断表示[按钮中断]                                                                                              #
###############################################################################################################################*/
#INT_EXT1
void externa1_interrupt(void) {
    clear_interrupt(INT_EXT1);          //##(0)中断标志清零
    regs.flags.NoWdtWakeup |= 1;        //##(0)设置不是看门狗唤醒
} 
/*###############################################################################################################################
# 函数名 :  void external_interrupt1(void)                                                                                      #
# 功  能 :  外部中断[1]函数                                                                                                     #
# 参  数 :  NONE                                                                                                                #
# 说  明 :  设定中断表示[按钮中断]                                                                                              #
###############################################################################################################################*/
#INT_EXT2 
void externa2_interrupt(void) {
    clear_interrupt(INT_EXT2);          //##(0)中断标志清零
    regs.flags.NoWdtWakeup |= 1;        //##(0)设置不是看门狗唤醒
} 
/*###############################################################################################################################
# 函数名 :  void external_interrupt1(void)                                                                                      #
# 功  能 :  外部中断[1]函数                                                                                                     #
# 参  数 :  NONE                                                                                                                #
# 说  明 :  设定中断表示[按钮中断]                                                                                              #
###############################################################################################################################*/
#INT_EXT3
void externa3_interrupt(void) {
    clear_interrupt(INT_EXT3);          //##(0)中断标志清零
    regs.flags.Sensor1 = true;          //##(0)传感器"1"检测触发中断标志 = 1 
    regs.flags.NoWdtWakeup |= 1;        //##(0)设置不是看门狗唤醒
} 
/*###############################################################################################################################
# 函数名 :  void external_interrupt1(void)                                                                                      #
# 功  能 :  外部中断[1]函数                                                                                                     #
# 参  数 :  NONE                                                                                                                #
# 说  明 :  设定中断表示[按钮中断]                                                                                              #
###############################################################################################################################*/
#INT_EXT4
void externa4_interrupt(void) {
    clear_interrupt(INT_EXT4);          //##(0)中断标志清零
    regs.flags.Sensor2 = true;          //##(0)传感器"2"检测触发中断标志 = 1
    regs.flags.NoWdtWakeup |= 1;        //##(0)设置不是看门狗唤醒
} 
/*###############################################################################################################################
# 函数名 : void Eusart1_interrupt(void)                                                                                         #
# 功  能 : 串口中断(最高优先级)                                                                                                 #
# 参  数 : NONE                                                                                                                 #
# 说  明 : 不做过多处理数据以免错漏数据 (从进入中断到退出中断耗时 0.5us)                                                        #  
###############################################################################################################################*/ 
#INT_RDA Level = 7 
void uart_interrupt(void) { 
    regs.rxTimeout = 0;                 //##(0)由于采用"DMA"传输,当接收字节中断则将接收数据超时计时器(没有收到字节检测)清零 
}
/*###############################################################################################################################
# 函数名  :  void Timer2_interrupts(void)                                                                                       #
# 功  能  :  定时器4中断(2毫秒中断一次),检查串口接收的数据，判断接收数据结束                                                    #
# 参  数  :  NONE                                                                                                               #
# 说  明  :  如果4毫秒(2ms中断一次)无数据则认为帧数据接收完成,次高优先级,串口采用"DMA"接收不定长字节，耗时 ： 0.8us             #                            
###############################################################################################################################*/
#INT_TIMER4 Level = 6                         
void timer4_interrupts(void) {
    clear_interrupt(INT_TIMER4);                        //##(0)清除中断标志  
    uart.ReceiveCompleted |= (++regs.rxTimeout>=10);    //##(0)有接收到数据则在串口接收中断将"regs.rxTimeout"清零
}
/*###############################################################################################################################
# 声明结束                                                                                                                      #
###############################################################################################################################*/
#ifdef	__cplusplus
}
#endif
#endif

