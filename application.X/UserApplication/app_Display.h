/*###############################################################################################################################
 # 文件名称 ： u80711R01_CONFIG_H.H                                                                                             #
 # 公司名称 :  TOTEX Technology, Inc.                                                                                           #
 # 芯片型号 ： PIC24FJ128GA302                                                                                                  #
 # 编译工具 :  ccs compiler v5.118                                                                                              #
 # 作    者 :  BenZhang                                                                                                         #
 # 编写日期 :  2025/11/10                                                                                                       #
 # 版    本 :  v1.00                                                                                                            #
 ##############################################################################################################################*/
#ifndef APP_REB_LED_H
#define	APP_REB_LED_H
/*###############################################################################################################################
# 包含文件                                                                                                                      #
###############################################################################################################################*/
#include "app_config.h"
/*###############################################################################################################################
#  应用声明开始                                                                                                                 #
###############################################################################################################################*/
#ifdef	__cplusplus
extern "C" {
#endif
/*###############################################################################################################################
#  颜色宏声明                                                                                                                   #
###############################################################################################################################*/
                                            //##(0 绿色(HSB) -> 红色(MSB) -> 蓝色(LSB)
#define BLACK               0x00000000      //##(0)黑色
#define Green               0x000000FF      //##(0)绿色
#define RED                 0x0000FF00      //##(0)红色
#define Blue                0x00FF0000      //##(0)蓝色
#define White               0x00FFFFFF      //##(0)白色
#define Purple              0x00FFFF00      //##(0)紫色
/*###############################################################################################################################
#  颜色转换,定点数宏定义                                                                                                        #
###############################################################################################################################*/     
#define FIXED_SHIFT          6U                                                 //##(0)小数位：6位（1.0 = 64 = 1<<6）
#define FIXED_1             (1U << FIXED_SHIFT)                                 //##(0)代表 1.0（64）
#define FIXED_1_6           (FIXED_1 / 6U)                                      //##(0)代表 1/6 ≈ 10
#define FIXED_1_2           (FIXED_1 / 2U)                                      //##(0)代表 1/2 = 32
#define FIXED_2_3           ((FIXED_1 * 2U) / 3U)                               //##(0)代表 2/3 ≈ 42
#define UINT8_TO_FIXED(x)   ((int32_t)(x) * FIXED_1 / 255U)                     //##(0)0~255 → 0~FIXED_1
#define FIXED_TO_UINT8(x)   ((uint8_t)(((x) * 255U + FIXED_1/2U) / FIXED_1))    //##(0)定点数→0~255（四舍五入） 
#define HueOffset           (255.f/360.f)                                       //##(0)360°转为8位色度(255°)的偏移增益    
#define DIV_CEIL(a, b)      ((a + b - 1) / b)                                   //##(0)辅助宏：除法向上取整
/*###############################################################################################################################
#  变量类型声明                                                                                                                 #
###############################################################################################################################*/
typedef struct {                //##(0)三基色结构体,由于驱动芯片三基色驱动顺序导致需要按照以下顺序排列
    uint8_t g;                  //##(0)绿色【0-255】
    uint8_t r;                  //##(0)红色【0-255】
    uint8_t b;                  //##(0)蓝色【0-255】  
    uint8_t a;                  //##(0)透明度【0-100,100 = 不透明】
}color;                         //##(0)RGB颜色结构体
typedef struct {                //##(0)三基色结构体,由于驱动芯片三基色驱动顺序导致需要按照以下顺序排列
   uint16_t H;                  //##(0)色度【0-360】
    uint8_t S;                  //##(0)饱和度【0-100】
    uint8_t L;                  //##(0)亮度【0-100】  
    uint8_t A;                  //##(0)透明度【0-100,100 = 不透明】
}colorHSL;                      //##(0)RGB颜色结构体
__attribute__((aligned(4))) color FrameRGB[8];
__attribute__((aligned(4))) color LEDBUFF[8];

#define STATE_NONE  0x00        //##(0)无显示模式    
#define STATICM     0x01        //##(0)静态显示模式
#define FADEM       0x02        //##(0)渐变显示模式
#define CHASERM     0x03        //##(0)跑马灯显示模式    
#define BLINKM      0x04        //##(0)闪烁显示模式 
/*###############################################################################################################################
# LED变量声明                                                                                                                   #
# 动画类型                                                                                                                      #
# 0x01 – 静态（STATIC）                                                                                                        #
          使用 HSL 色彩模式呈现固定颜色 。                                                                                      #
# 0x02 – 渐变（FADE）                                                                                                          #
          在两种 HSL 颜色之间随时间渐变，可选择是否循环 。对于循环渐变动画，需实现 “呼吸灯” 效果：颜色在两种 HSL 值之间先渐入 #
          再渐出，循环往复。                                                                                                    #
# 0x03 – 追逐（CHASER）                                                                                                        #
          按序列点亮 LED，采用 HSL 色彩模式并为每个 LED 设置相位偏移。相位偏移定义了相邻 LED 点亮的延迟时间，每个 LED 会从起始  #
          HSL 颜色渐变至终止 HSL 颜色。                                                                                         #
# 0x04 – 闪烁（BLINK）                                                                                                         #                                     
          在两种 HSL 颜色之间渐变，短暂保持目标颜色后反向渐变，最终回到初始颜色并短暂停留。                                     #
 ##############################################################################################################################*/
#define AnimQy	 30                 //##(0)动画组数量
typedef struct{
    uint8_t mode;                   //##(0)显示模式【静态(STATIC)/渐变(FADE)/追逐(CHASER)/闪烁(BLINK)】
    uint8_t LEDS;                   //##(0)LED 位图,最高位对应"LED0"
    uint8_t StartH;                 //##(0)起始色相    （0-360度对应不同颜色）
    uint8_t StartS;                 //##(0)起始饱和度  （0%-100%）
    uint8_t StartL;                 //##(0)起始亮度    （0%-100%）
    uint8_t EndingH;                //##(0)结束色相    （0-360度对应不同颜色）
    uint8_t EndingS;                //##(0)结束饱和度  （0%-100%）
    uint8_t EndingL;                //##(0)结束亮度    （0%-100%）
   uint16_t Duration;               //##(0)显示持续时间（单位:毫秒）
    uint8_t RepeatCount;            //##(0)显示重复计数,此值为"0"则死循环 
    uint8_t NextInChain;            //##(0)显示链中的下一帧 
   uint16_t Parameter1;             //##(0)动画类型特定参数1,如果显示模式是追逐（CHASER）显示,此值为LED点亮间隔时间(表示多个灯组之间的启动错开程度)
   uint16_t Parameter2;             //##(0)动画类型特定参数2,如果显示模式是追逐（CHASER）显示,此值为"0"则LED0->LED8依次顺序             
}Animation;                         //##(0)每帧动画声明(一个动画有5帧)
volatile Animation Frame[5];                 //##(0)1个动画 = 5 帧 = 80 字节 = 40 个 Modbus 寄存器
volatile Animation LEDAnim[AnimQy][5];       //##(0)共有30组动画,每组动画有5帧，全部字节数 = 16 * 5 * 30 = 2400个字节
#LOCATE LEDAnim = 0x1100;           //##(0)保存20组动画二维数组的所在RAM中的首地址
/*###############################################################################################################################
#  设置相应LED显示颜色                                                                                                          #
###############################################################################################################################*/
#define LED_SET_COLOR(LEDS, rgb, LEDBUFF)   \
do{                                         \
    uint8_t i = 0, mask = (LEDS);           \
    for(; i < 8; i++, mask >>= 1) {         \
        if(mask & 1U) {LEDBUFF[i] = (rgb);} \
    }                                       \
}while(0)
/*###############################################################################################################################
#  启动显示动画帧 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】                                                             #
###############################################################################################################################*/
const Animation PowerOnAnimation[4] = {
    {STATICM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x01, 0x0000, 0x0000},
    {CHASERM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x7800, 0x01, 0x02, 0x0000, 0x0000},    
    {STATICM, 0b11111111, 0x00, 0x00, 0x64, 0x00, 0x00, 0x64, 0xC800, 0x01, 0x03, 0x0000, 0x0000},
    {FADEM,   0b11111111, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x5802, 0x01, 0x04, 0x0000, 0x0000}
};
/*###############################################################################################################################
#  开机显示动画帧 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】                                                             #
###############################################################################################################################*/
const Animation PowerOffAnimation[3] = {
    {FADEM  , 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x5802, 0x01, 0x01, 0x0000, 0x0000},  
    {STATICM, 0b11111111, 0x00, 0x00, 0x64, 0x00, 0x00, 0x64, 0xC800, 0x01, 0x02, 0x0000, 0x0000},  
    {CHASERM, 0b11111111, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x7800, 0x01, 0x03, 0x0000, 0x0100}   
};
/*###############################################################################################################################
#  故障显示动画帧 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】闪烁10次                                                     #
###############################################################################################################################*/
const Animation OffAnimation[1] = {
    {STATICM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0, 1, 0x0000, 0x0000}
};
/*###############################################################################################################################
#  故障显示动画帧 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】闪烁25(30S)次                                                #
###############################################################################################################################*/
const Animation ErrorAnimation[2] = {
    {BLINKM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x64, 0x32, 0x9001, 0x19, 0x01, 0xC800, 0xC800},
    {STATICM,0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x02, 0x0000, 0x0000}
};
/*###############################################################################################################################
#  通讯显示动画帧 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】闪烁25(30S)次                                                #
###############################################################################################################################*/
const Animation commFaultAnimation[2] = {
    {BLINKM, 0b11111111, 0x00, 0x00, 0x00, 0x25, 0x64, 0x32, 0x9001, 0x19, 0x01, 0xC800, 0xC800},	
    {STATICM,0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x02, 0x0000, 0x0000}
};
/*###############################################################################################################################
#  充电显示SOC动画帧(5%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,"LED1"闪烁                                           #
###############################################################################################################################*/
const Animation ChgSoc5Animation[1] = {
    {BLINKM, 0b10000000, 0x00, 0x00, 0x00, 0x00, 0x64, 0x32, 0x6400, 0x00, 0x01, 0x2C01, 0x2C01}
};
/*###############################################################################################################################
#  充电显示SOC动画帧(6%-->15%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1"全亮,"LED2"闪烁                      #
###############################################################################################################################*/
const Animation ChgSoc6Animation[2] = {
    {STATICM,0b11000000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x01, 0x0000, 0x0000},
    {BLINKM, 0b01000000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x2C01, 0x00, 0x02, 0x2C01, 0x2C01}
};
/*###############################################################################################################################
#  充电显示SOC动画帧(16%-->30%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED2"全亮,"LED3"闪烁                #
###############################################################################################################################*/
const Animation ChgSoc16Animation[2] = {
    {STATICM,0b11100000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x01, 0x0000, 0x0000},
    {BLINKM, 0b00100000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x2C01, 0x00, 0x02, 0x2C01, 0x2C01}
};
/*###############################################################################################################################
#  充电显示SOC动画帧(31%-->45%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED3"全亮,"LED4"闪烁                #
###############################################################################################################################*/
const Animation ChgSoc31Animation[2] = {
    {STATICM,0b11110000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x01, 0x0000, 0x0000},
    {BLINKM, 0b00010000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x2C01, 0x00, 0x02, 0x2C01, 0x2C01}
};
/*###############################################################################################################################
#  充电显示SOC动画帧(46%-->60%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED4"全亮,"LED5"闪烁                #
###############################################################################################################################*/
const Animation ChgSoc46Animation[2] = {
    {STATICM,0b11111000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x01, 0x0000, 0x0000},
    {BLINKM, 0b00001000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x2C01, 0x00, 0x02, 0x2C01, 0x2C01}
};
/*###############################################################################################################################
#  充电显示SOC动画帧(61%-->75%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED5"全亮,"LED6"闪烁                #
###############################################################################################################################*/
const Animation ChgSoc61Animation[2] = {
    {STATICM,0b11111100, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x01, 0x0000, 0x0000},
    {BLINKM, 0b00000100, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x2C01, 0x00, 0x02, 0x2C01, 0x2C01}
};
/*###############################################################################################################################
#  充电显示SOC动画帧(76%-->90%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED6"全亮,"LED7"闪烁                #
###############################################################################################################################*/
const Animation ChgSoc76Animation[2] = {
    {STATICM,0b11111110, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x01, 0x0000, 0x0000},
    {BLINKM, 0b00000010, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x2C01, 0x00, 0x02, 0x2C01, 0x2C01}
};
/*###############################################################################################################################
#  充电显示SOC动画帧(91%-->99%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED7"全亮,"LED8"闪烁                #
###############################################################################################################################*/
const Animation ChgSoc91Animation[2] = {
    {STATICM,0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x01, 0x0000, 0x0000},
    {BLINKM, 0b00000001, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x2C01, 0x00, 0x02, 0x2C01, 0x2C01}
};
/*###############################################################################################################################
#  充电显示SOC动画帧(电池充满) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED"全亮                                  #
###############################################################################################################################*/
const Animation ChgSoc100Animation[1] = {
    {STATICM,0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x01, 0x0000, 0x0000}
};

/*###############################################################################################################################
#  待机显示SOC动画帧(5%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,"LED1"闪烁                                           #
###############################################################################################################################*/
const Animation Soc5Animation[2] = {
    {STATICM,0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x01, 0x0000, 0x0000},
    {BLINKM, 0b10000000, 0x00, 0x00, 0x00, 0x00, 0x64, 0x32, 0x3200, 0x04, 0x00, 0x2C01, 0x2C01}  
};
/*###############################################################################################################################
#  待机显示SOC动画帧(6%~16%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1"全亮,"LED2"闪烁                      #
###############################################################################################################################*/
const Animation Soc6Animation[4] = {
    {STATICM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x01, 0x0000, 0x0000},
    {CHASERM, 0b11000000, 0x00, 0x00, 0x00, 0x00, 0x64, 0x32, 0x0A00, 0x01, 0x02, 0x3200, 0x0000}, 
    {STATICM, 0b11000000, 0x00, 0x64, 0x32, 0x00, 0x64, 0x32, 0xD007, 0x01, 0x03, 0x0000, 0x0000},
    {FADEM,   0b11000000, 0x00, 0x64, 0x32, 0x00, 0x00, 0x00, 0x2C01, 0x01, 0x04, 0x0000, 0x0000}
};
/*###############################################################################################################################
#  待机显示SOC动画帧(17%--25%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED2"全亮,"LED3"闪烁                #
###############################################################################################################################*/
const Animation Soc17Animation[4] = {
    {STATICM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x01, 0x0000, 0x0000},    
    {CHASERM, 0b11100000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x02, 0x3200, 0x0000},  
    {STATICM, 0b11100000, 0x00, 0x00, 0x64, 0x00, 0x00, 0x64, 0xD007, 0x01, 0x03, 0x0000, 0x0000},   
    {FADEM,   0b11100000, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x2C01, 0x01, 0x04, 0x0000, 0x0000}
};
/*###############################################################################################################################
#  充电显示SOC动画帧(26%--50%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED3"全亮,"LED4"闪烁                #
###############################################################################################################################*/
const Animation Soc26Animation[4] = {
    {STATICM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x01, 0x0000, 0x0000},  
    {CHASERM, 0b11110000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x02, 0x3200, 0x0000},   
    {STATICM, 0b11110000, 0x00, 0x00, 0x64, 0x00, 0x00, 0x64, 0xD007, 0x01, 0x03, 0x0000, 0x0000}, 
    {FADEM,   0b11110000, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x2C01, 0x01, 0x04, 0x0000, 0x0000}
};
/*###############################################################################################################################
#  待机显示SOC动画帧(51%--70%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED4"全亮,"LED5"闪烁                #
###############################################################################################################################*/
const Animation Soc51Animation[4] = {
    {STATICM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x01, 0x0000, 0x0000},
    {CHASERM, 0b11111000, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x02, 0x3200, 0x0000},    
    {STATICM, 0b11111000, 0x00, 0x00, 0x64, 0x00, 0x00, 0x64, 0xD007, 0x01, 0x03, 0x0000, 0x0000},
    {FADEM,   0b11111000, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x2C01, 0x01, 0x04, 0x0000, 0x0000}
};
/*###############################################################################################################################
#  待机显示SOC动画帧(71%--80%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED5"全亮,"LED6"闪烁                #
###############################################################################################################################*/
const Animation Soc71Animation[4] = {
    {STATICM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x01, 0x0000, 0x0000},
    {CHASERM, 0b11111100, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x02, 0x3200, 0x0000},    
    {STATICM, 0b11111100, 0x00, 0x00, 0x64, 0x00, 0x00, 0x64, 0xD007, 0x01, 0x03, 0x0000, 0x0000},
    {FADEM,   0b11111100, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x2C01, 0x01, 0x04, 0x0000, 0x0000}
};
/*###############################################################################################################################
#  待机显示SOC动画帧(81%--90%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED6"全亮,"LED7"闪烁                #
###############################################################################################################################*/
const Animation Soc81Animation[4] = {
    {STATICM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x01, 0x0000, 0x0000},
    {CHASERM, 0b11111110, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x02, 0x3200, 0x0000},    
    {STATICM, 0b11111110, 0x00, 0x00, 0x64, 0x00, 0x00, 0x64, 0xD007, 0x01, 0x03, 0x0000, 0x0000},
    {FADEM,   0b11111110, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x2C01, 0x01, 0x04, 0x0000, 0x0000} 
};
/*###############################################################################################################################
#  待机显示SOC动画帧(91%--100%) 【模式,LEDS,H,S,L,H,S,L,时长,重复,下一个,P1,P2}】,全部"LED1~LED7"全亮,"LED8"闪烁                #
###############################################################################################################################*/
const Animation Soc91Animation[4] = {
    {STATICM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0000, 0x01, 0x01, 0x0000, 0x0000},
    {CHASERM, 0b11111111, 0x00, 0x00, 0x00, 0x00, 0x00, 0x64, 0x0A00, 0x01, 0x02, 0x3200, 0x0000},    
    {STATICM, 0b11111111, 0x00, 0x00, 0x64, 0x00, 0x00, 0x64, 0xD007, 0x01, 0x03, 0x0000, 0x0000},
    {FADEM,   0b11111111, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x2C01, 0x01, 0x04, 0x0000, 0x0000} 
};

/*###############################################################################################################################
#  函数声明                                                                                                                     #
###############################################################################################################################*/
void write_E263HEGBK(uint32_t colorData);
void DisplayLED(uint32_t colorData);
color HSL_TO_RGBA(uint16_t h, uint8_t S, uint8_t L, uint8_t a);
/*###############################################################################################################################
# 函数名  :  void resetRGBLED(void)                                                                                             #
# 功  能  :  发送复位RGB信号                                                                                                    #
# 参  数  :  NONE                                                                                                               #
# 说  明  :  按照资料上时许写入(从数据最低位写起)                                                                               #
###############################################################################################################################*/
void resetRGBLED(void) {
    PUST_0;
    delay_us(250);
}
/*###############################################################################################################################
# 函数名  :  uint32_t reverse24(uint32_t color)                                                                                 #
# 功  能  :  把 24bit 颜色（BGR）的每个字节，内部位反转                                                                         #
# 参  数  :  NONE                                                                                                               #
# 说  明  :  NONE                                                                                                               #
###############################################################################################################################*/
uint32_t reverse24(uint32_t color) {
   
    uint8_t b = (color >> 16) & 0xFF;               //##(0)取出最高字节"BLUE" (bit16~bit23) 
    uint8_t g = (color >> 8)  & 0xFF;               //##(0)取出中间字节"GREEN"(bit8~bit15) 
    uint8_t r = (color & 0xFF);                     //##(0)取出最低字节"RED"  (bit0~bit7)   
//##(0)对 B 字节做同样位反转
    b = ((b >> 1) & 0x55) | ((b << 1) & 0xAA);      //##(0)交换相邻 1 位：bit0 ↔ bit1，bit2 ↔ bit3...
    b = ((b >> 2) & 0x33) | ((b << 2) & 0xCC);
    b = ((b >> 4) & 0x0F) | ((b << 4) & 0xF0);
 //##(0)对 R 字节做同样位反转
    r = ((r >> 1) & 0x55) | ((r << 1) & 0xAA);      //##(0)交换相邻 4 位：bit0-3  bit4-7
    r = ((r >> 2) & 0x33) | ((r << 2) & 0xCC);
    r = ((r >> 4) & 0x0F) | ((r << 4) & 0xF0);  
//##(0)对 G 字节做同样位反转    
    g = ((g >> 1) & 0x55) | ((g << 1) & 0xAA);      //##(0)交换相邻 2 位：bit0-1  bit2-3...
    g = ((g >> 2) & 0x33) | ((g << 2) & 0xCC);
    g = ((g >> 4) & 0x0F) | ((g << 4) & 0xF0);

//##(0)把反转后的 B、G、R 重新拼成 24bit
    return ((uint32_t)b << 16) | ((uint32_t)g << 8) | r;
}
/*###############################################################################################################################
# 函数名  :  void write_E263HEGBK(uint32_t colorData)                                                                           #
# 功  能  :  向 E263HEGBK 驱动芯片发送 24bit 颜色数据                                                                           #
# 参  数  :  NONE                                                                                                               #
# 说  明  :  NONE                                                                                                               #
###############################################################################################################################*/
void write_E263HEGBK(uint32_t colorData) {
    uint8_t txh_time, txl_time;                     //##(0)高电平/低电平时间,数据 
    uint8_t bits;                                   //##(0)字节/数据位
//##(0)对 24bit 颜色做【位反转】（由于硬件问题造成必须要)         
    colorData = reverse24(colorData);
//##(0)连续发送24位数据到驱动器芯片中
    for(bits=0; bits<24; bits++) {                  //##(0)连续写入24位颜色数据,顺序 B->G->R 
        if(!bit_test(colorData,bits)) {             //##(0)判断数据当前循环位是"0"或者"1"?       
            txh_time = T0H;                         //##(0)发送"0"高电平延时时间
            txl_time = T0L;                         //##(0)发送"0"低电平延时时间
        }else{
            txh_time = T1H;                         //##(0)发送"1"高电平延时时间
            txl_time = T1L;                         //##(0)发送"1"低电平延时时间
        }
        PUST_1;                                     //##(2)发送一个bit时序
        delay_cycles(txh_time);                     //##(3)高电平延时
        PUST_0; 
        delay_cycles(txl_time);                     //##(4)低电平延时  
    }
}
/*###############################################################################################################################
# 函数名 :  void DisplayLED(uint32_t Data)                                                                                      #
# 功  能 :  LED显示三基色数据                                                                                                   #
# 参  数 :  NONE                                                                                                                #
# 说  明 :  NONE                                                                                                                #
###############################################################################################################################*/
void DisplayLED(uint32_t colorData) {
    uint8_t bytes;										
//##(0)连续写入8个LED的三基色数据
    for(bytes=0; bytes<8; bytes++) {                                                        
        write_E263HEGBK(colorData);
    } 
}
/*###############################################################################################################################
# 函数名 :  void DisplayLED(uint32_t Data)                                                                                      #
# 功  能 :  LED显示三基色数据(一次性显示8个LED阵列数据)                                                                         #
# 参  数 :  NONE                                                                                                                #
# 说  明 :  NONE                                                                                                                #
###############################################################################################################################*/
void DisplayFrameRGB(uint32_t *colorData) {
    uint8_t bytes;										
//##(0)连续写入8个LED的三基色数据
    for(bytes=0; bytes<8; bytes++) {                                                        
        write_E263HEGBK(colorData[bytes]);                                            
    } 
}
/*###############################################################################################################################
 * @brief HSL转RGBA核心函数,耗时 = 最长(320us) 最短(2us)                                                                        #
 * @param h 色相 (0-360)                                                                                                        #
 * @param s 饱和度 (0-100，百分比)                                                                                              #
 * @param l 亮度 (0-100，百分比)                                                                                                #
 * @param a 透明度 (0-255，直接传入RGBA的Alpha通道)                                                                             #
 * @return 转换后的RGBA颜色结构体，PIC24FJ128GL305 32MHz 需要1.5ms+ 执行时间                                                    #
###############################################################################################################################*/
color HSL_TO_RGBA(uint16_t H, uint8_t S, uint8_t L, uint8_t A) { 
    color rgba;
//##(0)直接赋值透明度  
    rgba.a = A;  
//##(1)处理特殊情况：亮度为0（全黑）或100（全白）
    if(L == 0)   { rgba.r = 0;   rgba.g = 0;   rgba.b = 0;   return rgba;}  //##(0)亮度为"0"返回 RGB = 0  (黑色/关闭)
    if(L == 100) { rgba.r = 255; rgba.g = 255; rgba.b = 255; return rgba;}  //##(0)亮度为"0"返回 RGB = 255(白色/开启)
//##(2)归一化处理：将百分比转为0.0-1.0的浮点值（精简浮点运算）
    float s_norm = (float)S * 0.01f;
    float l_norm = (float)L * 0.01f;
//##(3)计算HSL转RGB的核心参数
    float c = (1.0f - fabs(2.0f * l_norm - 1.0f)) * s_norm;     //##(0)色度
//##(0)色相计算
    //float h_norm = (float)H * HueOffset * (6.0f / 255.0f);      //##(0)H数值为(0 - 255) 色相归一化到 0°- 360°色相
     float h_norm = (float)(H % 360) * 0.0166667f;                       //##(0)H数值为(0 - 360) 色相归一化到 0°- 360°色相
    float x = c * (1.0f - fabs(fmod(h_norm, 2.0f) - 1.0f));     //##(0)辅助参数
    float r_temp = 0.0f, g_temp = 0.0f, b_temp = 0.0f;          //##(0)初始化 "RGB"暂存数值
//##(4)根据色相区间分配临时值
    if (h_norm >= 0 && h_norm < 1) {
        r_temp = c;
        g_temp = x;
        b_temp = 0;
    } else if (h_norm >= 1 && h_norm < 2) {
        r_temp = x;
        g_temp = c;
        b_temp = 0;
    } else if (h_norm >= 2 && h_norm < 3) {
        r_temp = 0;
        g_temp = c;
        b_temp = x;
    } else if (h_norm >= 3 && h_norm < 4) {
        r_temp = 0;
        g_temp = x;
        b_temp = c;
    } else if (h_norm >= 4 && h_norm < 5) {
        r_temp = x;
        g_temp = 0;
        b_temp = c;
    } else if (h_norm >= 5 && h_norm < 6) {
        r_temp = c;
        g_temp = 0;
        b_temp = x;
    }
//##(0)亮度偏移量
    float m = l_norm - c * 0.5f;
//##(0)转换为8位RGB值（0-255）并四舍五入
    rgba.r = (uint8_t)((r_temp + m) * 255.0f + 0.5f);
    rgba.g = (uint8_t)((g_temp + m) * 255.0f + 0.5f);
    rgba.b = (uint8_t)((b_temp + m) * 255.0f + 0.5f);
//##(0)返回RGB
    return (rgba);
}
/*###############################################################################################################################
# 函数名 : 拷贝颜色数组                                                                                                         #
###############################################################################################################################*/
static void copyRegisters(color *data1, color *data2) {
    data1[0] = data2[0];
    data1[1] = data2[1];
    data1[2] = data2[2];
    data1[3] = data2[3];
    data1[4] = data2[4];
    data1[5] = data2[5];
    data1[6] = data2[6];
    data1[7] = data2[7];
}
/*###############################################################################################################################
# 函数名 :  bool ChaserMode(uint8_t LEDS, colorHSL Start, colorHSL End, uint16_t Duration, bool direction, uint16_t Parameter1) #
# 功  能 :  "LED"追逐显示模式(跑马灯模式)带渐变过渡                                                                             #
# 参  数 :    LEDS = 需要显示的"LED"位图 ,                                                                                      #     
#            Start = 初始显示颜色  , End : 需要显示的颜色 ， Duration = 显示当前"LED"保持时间 ,                                 #
#            Parameter1 = 如果显示模式是追逐（CHASER）显示,此值为LED点亮间隔时间(表示多个灯组之间的启动错开程度)                #    
# 说  明 :  显示完成则返回"1",否则返回"0"                                                                                       #
###############################################################################################################################*/
bool ChaserMode(Animation *Anim) {
    static uint16_t timeout;                    //##(0)时间戳，保存每个阶段起始的system5ms计时值，用于延时判断
    static uint16_t FadeStep;                   //##(0)当前渐变帧步进，记录渐变走到第几帧
    static  int8_t  FadeRng;                    //##(0)渐变范围(淡入淡出) 
    static boolean  FadeForward;                //##(0)渐变方向标志：true暗→亮；false亮→暗
    static boolean  ChaserForward;              //##(0)追逐方向
    static colorHSL COL;                        //##(0)颜色值缓存
    static uint8_t  LEDINX;                     //##(0)显示LED的索引, 正向跑马：LED0→LED7/反向跑马：LED7→LED0
    static uint16_t FRAMES = 0u;                //##(0)单向渐变总帧数，由渐变时长Duration计算得出
              color rgb;                        //##(0)临时缓存HSL转换后的RGB颜色
    static  uint8_t Repeat;                     //##(0)循环次数计数器
           uint32_t ratio;                      //##(0)比例,进度系数
            boolean status = false;             //##(0)函数返回标记，false=动画进行中；true=全部闪烁完成
    static uint16_t Parameter1;                 //##(0)相位偏移延时时间(每个LED显示间隔时间)
//##(0)其它模式状态机复位               
    SM_StateMachine = FM_StateMachine = BM_StateMachine = 0u;
//##(0)执行动画主状态机
    switch(CM_StateMachine) {
//##(0)状态0:动画初始化入口,首次启动/一轮全部跑完都会进这里重置参数
        case 0x00:
             Repeat = 0U;                                           //##(0)渐变步进计数器清零
             CM_StateMachine = 0x01;                    
             break;
        case 0x01:  
             FadeStep = 0U;                                         //##(0)渐变步进计数器清零
             Parameter1 = SWAP_U16(Anim->Parameter1)/5U;            //##(0) 
             ChaserForward = (Anim->Parameter2>>8 == 0U)? 0:1;      //##(0)跑马方向
             LEDINX = (ChaserForward==false)? 0x07 : 0x00;          //##(0)跑马方向【 0x00 :正向LED0→LED7，0x07:反向 LED7→LED0】
             FRAMES = SWAP_U16(Anim->Duration)/5U;                  //##(0)渐变时长转换为渐变所需帧数(5毫秒播放一帧)
             FRAMES = (FRAMES == 0U)? 1U : FRAMES;                  //##(0)防除零
             FadeRng = abs((int16_t)Anim->StartL-Anim->EndingL);    //##(0)计算出渐变跨度范围 
             if(FadeRng>100) { status = true; break; }              //##(0)如果范围超过100则认为是溢出直接返回
             if(Anim->StartL > Anim->EndingL) {                     //##(0)判断起始/结束亮度来决定渐变方向
                COL.H = Anim->StartH;                           
                COL.S = Anim->StartS;                               //##(0)色度/饱和度/亮度为亮度最大的色值                    
                FadeForward = TRUE;                                 //##(0)反向调节 : 亮→暗
             }else{                                              
                COL.H = Anim->EndingH;                          
                COL.S = Anim->EndingS;                              //##(0)色度/饱和度为亮度最大的色值              
                FadeForward = FALSE;                                //##(0)正向调节 : 暗→亮
             }
             timeout = regs.system5ms;                              //##(0)记录当前系统计时，作为下一阶段延时起点
             CM_StateMachine = 0x02;                                //##(0)指向下一步   
             break;
//##(0)状态1:执行 LED跑马灯动画 
        case 0x02:
             if(bit_test(Anim->LEDS,LEDINX)) {                       //##(1)当前LED无需渲染颜色则返回                       
                ratio = ((uint32_t)FadeStep*1000U)/FRAMES;           //##(1)仅亮度"L"渐变,H/S/A固定Start不变
                ratio = FadeRng * ratio / 1000U;                     //##(1)计算出调节量步进的渐变亮度值 
               (FadeForward==false)?
               (COL.L = Anim->StartL + ratio):                       //##(1)暗→亮；递增
               (COL.L = Anim->StartL - ratio);                       //##(1)亮→暗；递减 
                rgb = HSL_TO_RGBA(COL.H, COL.S, COL.L, COL.A);       //##(1)转换成可驱动三基色LED显示的RGB数据
                LEDBUFF[LEDINX] = rgb; 
                DisplayFrameRGB((uint32_t *)LEDBUFF);                //##(1)将LED缓冲区数据输出到硬件,点亮LED
                if(FadeStep++ < FRAMES) break;                       //##(1)渐变没有完成则返回接着渐变
                FadeStep =0U;                                        //##(1)渐变完成则将渐变步进清零
             }
             timeout = regs.system5ms;                              //##(1)记录当前系统计时，作为下一阶段延时起点
             CM_StateMachine = 0x03;                                //##(1)转入相位偏移延时
             break;   
//##(0)状态2: 执行相位偏移延时
        case 0x03:
             if(bit_test(Anim->LEDS,LEDINX)) {                      //##(2)如果当前"LED"无需渲染则无需延时
                if(regs.system5ms-timeout<Parameter1) break;        //##(2)相位偏移延时时间没到则接着延时
                timeout = regs.system5ms;  
             }
             if(ChaserForward == false) {
                if(LEDINX-- >0U) {CM_StateMachine = 2U; break;}     //##(2)反向追逐显示完成  
             }else{
                if(++LEDINX <8U) {CM_StateMachine = 2U; break;}     //##(2)正向追逐显示完成                
             }  
             if(Anim->RepeatCount>0) {                              //##(3)不是循环追逐显示
                if(++Repeat < Anim->RepeatCount) {
                    CM_StateMachine = 1U;                           //##(3)循环次数没有达到则继续追逐显示                       
                }else{
                    status = true;                                  //##(3)追逐显示次数达到则为本帧动画显示完成
                    copyRegisters(FrameRGB,LEDBUFF);                //##(3)保存最后一帧动画  
                    CM_StateMachine = 0U;                           //##(3)追逐动画显示结束
                } 
             }else{
                CM_StateMachine = 1U;                               //##(0)循环显示
             }
             break;
//##(0)异常状态兜底复位（防跑飞）
        default: 
             CM_StateMachine = 0u;  
             status = true; 
             break;   
    }
//##(0)返回状态
    return(status);
}
                 
/*###############################################################################################################################
# 函数名 :  bool StaticMode(uint8_t LEDS,colorHSL Start, colorHSL End)                                                          #
# 功  能 :  使用 HSL 色彩模式呈现固定颜色(静态显示模式)                                                                         #
# 参  数 :  LEDS = 需要显示的"LED"位图 ,                                                                                        #     
#           Start = 初始显示颜色  , End : 需要显示的颜色(无效) ，Duration = 显示当前"LED"保持时间                               #    
# 说  明 :  显示完成则返回"1",否则返回"0"                                                                                       #
###############################################################################################################################*/
bool StaticMode(Animation *Anim) {
    static uint16_t timeout;
    colorHSL COL;               //##(0)颜色值缓存
    color rgb;                  //##(0)临时缓存HSL转换后的RGB颜色
    boolean  status = false;    //##(0)函数返回标记，false=动画进行中；true=全部闪烁完成
//##(0)其它模式状态机复位               
    CM_StateMachine = FM_StateMachine = BM_StateMachine = 0u;                              
//##(0)执行显示状态机
    switch(SM_StateMachine) {
        case 0x00:
             copyRegisters(LEDBUFF,FrameRGB);                       //##(0)接着上一帧动画(快速拷贝,比 memcpy()快12/15倍))
             COL.H = Anim->StartH;                                  //##(0)起始色度 
             COL.S = Anim->StartS;                                  //##(0)起始饱和度
             COL.L = Anim->StartL;                                  //##(0)起始亮度
             COL.A = 100;
             rgb = HSL_TO_RGBA(COL.H, COL.S, COL.L, COL.A);         //##(0)转换为可直接驱动LED的RGB三基色
             LED_SET_COLOR(Anim->LEDS,rgb,LEDBUFF);                 //##(0)根据LED掩码，给指定LED缓冲区填充当前渐变亮度  
             DisplayFrameRGB((uint32_t *)LEDBUFF);                  //##(0)驱动显示
             copyRegisters(FrameRGB,LEDBUFF);                       //##(0)保存当前帧动画数据(RGB数据)
             timeout = regs.system5ms;                              //##(0)记录当前系统计时，作为下一阶段延时起点
             SM_StateMachine = 0x01;                                //##(0)指向保持时间
             break;
        case 0x01:                                                  //##(0)持续显示"Duration"时间
             uint16_t duration = SWAP_U16(Anim->Duration);          //##(0)渐变时长【由于大小端原因,需要高低字节交换】  
             if(regs.system5ms-timeout<duration/5) break;			//##(0)显示持续时间 
             COL.H = Anim->EndingH;                                 //##(0)结束色度 
             COL.S = Anim->EndingS;                                 //##(0)结束饱和度
             COL.L = Anim->EndingL;                                 //##(0)结束亮度
             COL.A = 100;
             rgb = HSL_TO_RGBA(COL.H, COL.S, COL.L, COL.A);         //##(0)结束色转换为可驱动的三基色数据
             LED_SET_COLOR(Anim->LEDS,rgb,LEDBUFF);                 //##(0)根据LED掩码，给指定LED缓冲区填充当前渐变亮度
             DisplayFrameRGB((uint32_t *)LEDBUFF);                  //##(0)驱动显示
             copyRegisters(FrameRGB,LEDBUFF);                       //##(0)保存当前帧动画数据(RGB数据)
             SM_StateMachine = 0u;                                  //##(0)复位状态机
             timeout = regs.system5ms;
             status = true;                                         //##(0)执行完成
             break;    
//##(0)异常状态兜底复位（防跑飞）
        default: 
             SM_StateMachine = 0u; 
             status = true;
             break;   
    }
    return(status);                                                     //##(0)返回指向状态
}

/*###############################################################################################################################
# 函数名 :  bool FadeMode(uint8_t LEDS,colorHSL Start, colorHSL End)                                                            #
# 功  能 :  渐变模式 ,在两种 HSL 颜色之间随时间渐变(亮度渐变)                                                                   #
# 参  数 :  LEDS = 需要显示的"LED"位图 ,                                                                                        #     
#           Start = 初始显示颜色  , End : 需要显示的颜色 ，Duration = 显示当前"LED"保持时间                                     #    
# 说  明 :  显示完成则返回"1",否则返回"0"                                                                                       #
###############################################################################################################################*/
bool FadeMode(Animation *Anim) {
    static uint16_t timeout;                    //##(0)时间戳，保存每个阶段起始的system5ms计时值，用于延时判断
    static uint16_t FadeStep;                   //##(0)当前渐变帧步进，记录渐变走到第几帧
    static  int8_t  FadeRng;                    //##(0)渐变范围(淡入淡出)
    static colorHSL COL;                        //##(0)颜色值缓存
    static boolean  FadeForward;                //##(0)渐变方向标志：true暗→亮；false亮→暗
    static uint16_t MAX_FRAME = 0u;             //##(0)单向渐变总帧数，由渐变时长Duration计算得出
              color rgb;                        //##(0)临时缓存HSL转换后的RGB颜色
           uint32_t ratio;                      //##(0)比例,进度系数
            boolean status = false;             //##(0)函数返回标记，false=动画进行中；true=全部闪烁完成    
//##(0)其它模式状态机复位               
    CM_StateMachine = SM_StateMachine = BM_StateMachine = 0u;              
//##(0)执行动画主状态机
    switch(FM_StateMachine) {
//##(0)状态0:动画初始化入口,首次启动/一轮全部跑完都会进这里重置参数  
        case 0x00:
             FadeRng = abs((int16_t)Anim->StartL-Anim->EndingL);    //##(0)计算出渐变跨度范围 
             if(FadeRng>100) { status = true; break; }              //##(0)如果范围超过100则认为是溢出直接返回 
             MAX_FRAME = SWAP_U16(Anim->Duration)/5U;           //##(0)渐变过程需要的帧数,防除零
             MAX_FRAME = (MAX_FRAME==0U)? 1U:MAX_FRAME;         //##(0)防除零
             FadeStep = 0U;                                     //##(0)渐变步进计数器清零
             FM_StateMachine = 0x01;                            //##(0)状态机指向下一步(渐变动作) 
             timeout = regs.system5ms;                          //##(0)记录当前系统计时，作为下一阶段延时起点
             COL.A = 100;                                       //##(0)透明度
             if(Anim->StartL > Anim->EndingL) {                 //##(0)如果起始亮度大于结束亮度则为:亮→暗
                COL.H = Anim->StartH;                           
                COL.S = Anim->StartS;                           //##(0)色度/饱和度/亮度为亮度最大的色值                    
                FadeForward = TRUE;                             //##(0)反向调节
             }else{                                             //##(0) 
                COL.H = Anim->EndingH;                          
                COL.S = Anim->EndingS;                          //##(0)色度/饱和度为亮度最大的色值              
                FadeForward = FALSE;                            //##(0)正向调节
             }
             break;
//##(1)状态1:亮度渐变渲染阶段，控制每5ms刷新一帧渐变画面  
        case 0x01:
             copyRegisters(LEDBUFF,FrameRGB);                   //##(1)接着上一帧动画   
             ratio = ((uint32_t)FadeStep*1000U)/MAX_FRAME;      //##(1)仅亮度"L"渐变,H/S/A固定Start不变
             ratio = FadeRng * ratio / 1000U;                   //##(1)计算出调节量步进的渐变亮度值
            (FadeForward==false)?
            (COL.L = Anim->StartL + ratio):                     //##(1)暗→亮；递增
            (COL.L = Anim->StartL - ratio);                     //##(1)亮→暗；递减
             rgb = HSL_TO_RGBA(COL.H, COL.S, COL.L, COL.A);     //##(1)HSL颜色转换成硬件驱动需要的RGB格式
             LED_SET_COLOR(Anim->LEDS, rgb, LEDBUFF);           //##(1)根据LED掩码，给指定LED缓冲区填充当前渐变亮度 
             DisplayFrameRGB((uint32_t *)LEDBUFF);              //##(1)将LED缓冲区数据输出到硬件,点亮LED 
             if(FadeStep++ >= MAX_FRAME) {                      //##(1)检查是否完成单向渐变 ?
                FadeStep = 0U; FM_StateMachine = 0x02;          //##(1)完整渐变则状态机指向下一步
                copyRegisters(FrameRGB,LEDBUFF);                //##(0)保存最后显示的状态
             }
             timeout = regs.system5ms;                          //##(0)记录当前系统计时，作为下一阶段延时起点
             break;
//##(2)状态2 : 结束
        case 0x02: 
             FM_StateMachine = 0U;
             status = true;                                     //##(0)执行完成 
             break;        
        default:     
             FM_StateMachine = 0U;
             status = true;                                     //##(0)执行完成 
             break;        
    }
    return(status);
}
/*###############################################################################################################################
# 函数名 :  bool FadeMode(uint8_t LEDS,colorHSL Start, colorHSL End)                                                            #
# 功  能 :  渐变模式 ,在两种 HSL 颜色之间随时间渐变                                                                             #
# 参  数 :  LEDS = 需要显示的"LED"位图 ,                                                                                        #     
#           Start = 初始显示颜色  , End : 需要显示的颜色 ，Duration = 显示当前"LED"保持时间                                     #  
#           Duration = 渐变所耗时长                                                                                             #
#           Parameter1 = 亮度调节到目标保持时长  Parameter2 = 熄灭时长  count = 闪烁次数                                        #  
# 说  明 :  显示完成则返回"1",否则返回"0"（需要有呼吸模式）                                                                     #
###############################################################################################################################*/
bool BlinkMode(Animation *Anim) {
    static uint16_t timeout;                    //##(0)时间戳，保存每个阶段起始的system5ms计时值，用于延时判断
    static uint16_t FadeStep;                   //##(0)当前渐变帧步进，记录渐变走到第几帧
    static uint8_t  BlinkCount;                 //##(0)完整呼吸周期计数器，一轮明暗算1次,0 = 无限循环
    static  int8_t  FadeRng;                    //##(0)渐变范围(淡入淡出) 
    static boolean  FadeForward;                //##(0)渐变方向标志：true暗→亮；false亮→暗
    static colorHSL COL;                        //##(0)颜色值缓存
    static uint16_t BrightDur,DarkDur;          //##(0)TickBright = 高亮保持节拍(Parameter1), TickDark = 低亮熄灭保持节拍(Parameter2)
    static uint16_t MAX_FRAME = 0u;             //##(0)单向渐变总帧数，由渐变时长Duration计算得出
    static color rgb;                           //##(0)临时缓存HSL转换后的RGB颜色
           uint32_t ratio;                      //##(0)比例,进度系数
           boolean  status = false;             //##(0)函数返回标记，false=动画进行中；true=全部闪烁完成
           uint16_t HoldDelay;      
//##(0)复位其他动画状态机
    CM_StateMachine = SM_StateMachine = FM_StateMachine = 0U;    
//##(3)执行呼吸动画主状态机
    switch(BM_StateMachine) {
//##(0)状态0:动画初始化入口,首次启动/一轮全部跑完都会进这里重置参数        
        case 0x00:                                              
             Anim->Duration = SWAP_U16(Anim->Duration);         //##(0)渐变时长【由于大小端原因,需要高低字节交换】             
             Anim->Parameter1 = SWAP_U16(Anim->Parameter1);     //##(0)亮度最高保持时长
             Anim->Parameter2 = SWAP_U16(Anim->Parameter2);     //##(0)亮度最低保持时长
             FadeRng = abs((int16_t)Anim->StartL-Anim->EndingL);   //##(0)计算出渐变跨度范围  
             if(FadeRng>100) {status = true; break;}            //##(0)如果范围超过100则认为是溢出直接返回            
             BrightDur = Anim->Parameter1/5U;                   //##(0)亮保持时长
               DarkDur = Anim->Parameter2/5U;                   //##(0)关保持时长
             MAX_FRAME = Anim->Duration  /5U;                   //##(0)渐变过程需要的帧数,防除零
             MAX_FRAME = (MAX_FRAME==0U)? 1U:MAX_FRAME;         //##(0)防除零
              FadeStep = BlinkCount = 0U;                       //##(0)闪烁(渐变)周期计数器/渐变步进清零
             BM_StateMachine = 0x01;                            //##(0)状态机指向下一步(渐变动作) 
             if(Anim->StartL > Anim->EndingL) {                 //##(0)采用亮度最高的的色度/饱和度
                COL.H = Anim->StartH;  COL.S = Anim->StartS;    //##(0)起始色的色度/饱和度
                FadeForward = false;                            //##(0)起始亮度大于结束亮度则为正向渐变:亮变暗
             }else{
                COL.H = Anim->EndingH; COL.S = Anim->EndingS;   //##(0)结束色的色度/饱和度 
                FadeForward = true;                             //##(0)结束亮度大于起始亮度则为反向渐变:暗变亮
             }
             timeout = regs.system5ms;                          //##(0)记录当前系统计时，作为下一阶段延时起点
             break;
//##(1)状态1:亮度渐变渲染阶段，控制每5ms刷新一帧渐变画面             
        case 0x01:
             copyRegisters(LEDBUFF,FrameRGB);                   //##(1)接着上一帧动画             
             ratio = ((uint32_t)FadeStep*1000U)/MAX_FRAME;      //##(1)仅亮度"L"渐变,H/S/A固定Start不变
             ratio = FadeRng * ratio / 1000U;                   //##(1)计算出调节量步进的渐变亮度值
            (FadeForward==false)?
            (COL.L = Anim->StartL - ratio):                     //##(1) Anim->StartL > Anim->EndingL ,由暗到亮渐变  
            (COL.L = Anim->StartL + ratio);                     //##(1) Anim->EndingL > Anim->StartL ,由亮到暗渐变
             rgb = HSL_TO_RGBA(COL.H, COL.S, COL.L, COL.A);     //##(1)HSL颜色转换成硬件驱动需要的RGB格式
             LED_SET_COLOR(Anim->LEDS, rgb, LEDBUFF);           //##(1)根据LED掩码，给指定LED缓冲区填充当前渐变亮度   
             DisplayFrameRGB((uint32_t *)LEDBUFF);              //##(1)将LED缓冲区数据输出到硬件，点亮LED
             if(FadeStep++ >= MAX_FRAME) {                      //##(1)检查是否完成单向渐变 ?
                FadeStep = 0U; BM_StateMachine = 0x02;          //##(1)完成单向渐变,渐变步进清零/切换到纯色保持延时状态
             }
             timeout = regs.system5ms;                          //##(0)记录当前系统计时，作为下一阶段延时起点
             break;
//##(2)状态2 : 纯色保持延时阶段，区分高亮/暗态两套保持时长             
        case 0x02:                                              
             HoldDelay = (FadeForward)?  BrightDur:DarkDur;     //##(2)
             if((regs.system5ms-timeout)<HoldDelay) break;      //##(2)未到熄灭保持时间，等待下一轮
             timeout = regs.system5ms;                          //##(2)保持时长满足，刷新时间戳，准备反向渐变
             FadeForward = !FadeForward;                        //##(2)切换渐变方向
             Anim->StartL = FadeForward? 0U:FadeRng;            //##(2)重新配置初始值
             BM_StateMachine = 0x01;                            //##(2)回到渐变状态
             if(FadeForward == false) break;                    //##(2)一个显示周期没有完成则返回
             if(Anim->RepeatCount<=0) break;                    //##(0)一个周期完成则判断是否是一直循环 ?        
             if(++BlinkCount>=Anim->RepeatCount) {              //##(2))
                BM_StateMachine = 0x00; status = TRUE;          //##(0)状态机复位，动画结束
             }
             break;
//##(0)异常状态兜底复位（防跑飞）
        default: 
             BM_StateMachine = 0u; status = true; 
             break;                  
    }
    return(status);      
}
/*###############################################################################################################################
# 函数名 :  void AnimationDisplay_Process(void)                                                                                 #
# 功  能 :  动画显示进程                                                                                                        #
# 参  数 :  NONE                                                                                                                #
###############################################################################################################################*/
void AnimationDisplay_Process(Animation *pAnim) {
    static uint8_t StateMachine;
               bool state = false;
//##(0)如果没有动画显示使能,或者动画显示完成则清除显示动画帧(5帧)数组并返回 
    if(regs.flags.AnimEn == false) {
        memset(pAnim,0u,sizeof(Frame));             //##(0)全部帧动画数组清零(最多五帧动画)
        memset(FrameRGB,0u,sizeof(FrameRGB));       //##(0)最一帧动画数组清零
        StateMachine = regs.chain = 0;              //##(0)复位状态机和帧编号
        CM_StateMachine = SM_StateMachine = 0U;     //##(0)复位动画状态机 
        BM_StateMachine = FM_StateMachine = 0U;     //##(0)复位动画状态机 
        return; 
    }
//##(0)指向显示模式【静态(STATIC)/渐变(FADE)/追逐(CHASER)/闪烁(BLINK)】			   
    StateMachine = pAnim[regs.chain].mode;               
//##(0)有动画显示则按照显示步骤执行状态机器
    switch(StateMachine) {
        case STATE_NONE:                                     
             resetRGBLED();                             //##(0)先复位RGBLED
             regs.flags.AnimEn = false;                 //##(0)如果显示模式是"0"则表明显示完成本组动画全部帧,清除显示动画使能标志      
             break; 
        case STATICM: 
             state = StaticMode(&pAnim[regs.chain]);    //##(0)静态显示模式     
             break;
        case FADEM:
             state = FadeMode(&pAnim[regs.chain]);      //##(0)渐变显示模式 
             break;
        case CHASERM: 
             state = ChaserMode(&pAnim[regs.chain]);    //##(0)跑马灯显示模式 
             break;
        case BLINKM:
             state = BlinkMode(&pAnim[regs.chain]);     //##(0)闪烁显示模式
             break;         
        default:                
             regs.flags.AnimEn = false;                 //##(0)异常状态关闭显示（防跑飞） 
             return;
    }
//##(0)判断单帧是否完成 ? 显示完成重新复位状态机,继续显示下一帧动画
    if(state) { 
        if(regs.chain<5u) { regs.chain++; }             //##(0)在5帧范围内则接着下一帧动画             
        else              { regs.flags.AnimEn = 0; }    //##(0)大于5帧动画则直接结束动画
    }
}
/*###############################################################################################################################
# 函数名 :  void AnimationDisplay_Process(void)                                                                                 #
# 功  能 :  动画显示进程                                                                                                        #
# 参  数 :  NONE                                                                                                                #
###############################################################################################################################*/
void OnOff_StatusDisplay(boolean powerState) {
//##(0)先关闭定时器3中断以免中断和主线程同时读写这些全局结构体导致数据错乱
    disable_interrupts(INT_TIMER3);       
//##(0)先停止显示和清除显示缓存
    regs.flags.AnimEn = 0;
    AnimationDisplay_Process(&Frame);
//##(0)如果是开机则将开机动画数据拷贝到显示暂存器数组中
    if(powerState == powerOff) 
        memcpy(Frame,PowerOffAnimation,sizeof(PowerOffAnimation));    
    if(powerState == powerOn)
        memcpy(Frame,PowerOnAnimation,sizeof(PowerOnAnimation));  
//##(0)重新开启显示(显示新动画)    
    regs.flags.AnimEn = 1;
//##(0)恢复Timer3中断
    enable_interrupts(INT_TIMER3);   
}

/*###############################################################################################################################
# 函数名 :  void ChargingDisplay_RSOC(uint8_t rsoc)                                                                             #
# 功  能 :  充电显示相对容量                                                                                                    #
# 参  数 :  NONE                                                                                                                #
###############################################################################################################################*/
void ChargingDisplay(uint8_t rsoc) {
    disable_interrupts(INT_TIMER3);         //##(0)先关闭定时器3中断以免中断和主线程同时读写这些全局结构体导致数据错乱
    regs.flags.AnimEn = 0;                  //##(0)先停止显示和清除显示缓存
    AnimationDisplay_Process(&Frame);       //##(0)更新显示缓存
//##(0)根据状态更新相应的动画显示数据
         if(rsoc >=100)  { memcpy(Frame, ChgSoc100Animation, sizeof(ChgSoc100Animation));}    //##(0) 100
    else if(rsoc >= 91)  { memcpy(Frame, ChgSoc91Animation,  sizeof(ChgSoc91Animation)); }    //##(0) 91~99   
    else if(rsoc >= 76)  { memcpy(Frame, ChgSoc76Animation,  sizeof(ChgSoc76Animation)); }    //##(0) 76~90   
    else if(rsoc >= 61)  { memcpy(Frame, ChgSoc61Animation,  sizeof(ChgSoc61Animation)); }    //##(0) 61~75
    else if(rsoc >= 46)  { memcpy(Frame, ChgSoc46Animation,  sizeof(ChgSoc46Animation)); }    //##(0) 46~60
    else if(rsoc >= 31)  { memcpy(Frame, ChgSoc31Animation,  sizeof(ChgSoc31Animation)); }    //##(0) 31~45
    else if(rsoc >= 16)  { memcpy(Frame, ChgSoc16Animation,  sizeof(ChgSoc16Animation)); }    //##(0) 16~30
    else if(rsoc >= 6 )  { memcpy(Frame, ChgSoc6Animation,  sizeof(ChgSoc6Animation));   }    //##(0) 5~15 
    else                 { memcpy(Frame, ChgSoc5Animation,   sizeof(ChgSoc5Animation));  }    //##(0) 0~4
//##(0)重新开启显示(显示新动画)    
    regs.flags.AnimEn = 1;
    enable_interrupts(INT_TIMER3);       //##(0)恢复Timer3中断
}

/*###############################################################################################################################
# 函数名 :  void StandbyDisplay_RSOC(uint8_t rsoc)                                                                              #
# 功  能 :  待机显示相对容量                                                                                                    #
# 参  数 :  NONE                                                                                                                #
###############################################################################################################################*/
void StbyDisplay(uint8_t rsoc) {  
    if(regs.flags.AnimEn) return;           //##(0)如果当前正在显示动画则退出 
    disable_interrupts(INT_TIMER3);         //##(0)先关闭定时器3中断以免中断和主线程同时读写这些全局结构体导致数据错乱
    AnimationDisplay_Process(&Frame);       //##(0)先清除显示缓存
//##(0)根据状态更新相应的动画显示数据
         if(rsoc >= 91)  { memcpy(Frame, Soc91Animation,  sizeof(Soc91Animation)); }    //##(0) 91~100
    else if(rsoc >= 81)  { memcpy(Frame, Soc81Animation,  sizeof(Soc81Animation)); }    //##(0) 81~90
    else if(rsoc >= 71)  { memcpy(Frame, Soc71Animation,  sizeof(Soc71Animation)); }    //##(0) 71~80
    else if(rsoc >= 51)  { memcpy(Frame, Soc51Animation,  sizeof(Soc51Animation)); }    //##(0) 51~70
    else if(rsoc >= 26)  { memcpy(Frame, Soc26Animation,  sizeof(Soc26Animation)); }    //##(0) 26~50
    else if(rsoc >= 17)  { memcpy(Frame, Soc17Animation,  sizeof(Soc17Animation)); }    //##(0) 17~25
    else if(rsoc >= 6 )  { memcpy(Frame, Soc6Animation,   sizeof(Soc6Animation));  }    //##(0) 6~16
    else                 { memcpy(Frame, Soc5Animation,   sizeof(Soc5Animation));  }    //##(0) 0~4
//##(0)重新开启显示(显示新动画)    
    regs.flags.AnimEn = 1;
    enable_interrupts(INT_TIMER3);    //##(0)恢复Timer3中断
}
/*###############################################################################################################################
# 函数名 :  void FaultDisplay(void)                                                                                             #
# 功  能 :  刷新故障显示                                                                                                        #
# 参  数 :  NONE                                                                                                                #
###############################################################################################################################*/
void FaultDisplay(void) {
    disable_interrupts(INT_TIMER3);                         //##(2)关闭定时器3中断
    regs.flags.AnimEn = 0;                                  //##(2)停止显示当前动画
    AnimationDisplay_Process(&Frame);                       //##(2)清除显示动画暂存
    memcpy(Frame,ErrorAnimation,sizeof(ErrorAnimation));    //##(2)将故障动画数据更新到显示缓存    
	regs.flags.AnimEn = 1;                                  //##(2)重新使能动画显示
    enable_interrupts(INT_TIMER3);                          //##(2)恢复中断
}

/*###############################################################################################################################
# 函数名 :  void FaultDisplay(void)                                                                                             #
# 功  能 :  刷新故障显示[通讯故障显示橙色]                                                                                      #
# 参  数 :  NONE                                                                                                                #
###############################################################################################################################*/
void commFaultDisplay(void) {
    disable_interrupts(INT_TIMER3);								//##(2)关闭定时器3中断
    regs.flags.AnimEn = 0;										//##(2)停止显示当前动画
    AnimationDisplay_Process(&Frame);								//##(2)清除显示动画暂存
    memcpy(Frame,commFaultAnimation,sizeof(commFaultAnimation));	//##(2)将故障动画数据更新到显示缓存    
    regs.flags.AnimEn = 1;										//##(2)重新使能动画显示
    enable_interrupts(INT_TIMER3);								//##(2)恢复中断
}

/*###############################################################################################################################
# 函数名 :  void Display_off(void)																				  #
# 功  能 :  关闭显示																							  #
# 参  数 :  NONE                                                                                                                #
###############################################################################################################################*/
void Display_off(void) {
    uint8_t retry;
    disable_interrupts(INT_TIMER3);                     //##(2)关闭定时器3中断
    regs.flags.AnimEn = 0;                              //##(2)停止显示当前动画
    AnimationDisplay_Process(&Frame);                   //##(2)清除显示动画暂存
    memcpy(Frame,OffAnimation,sizeof(OffAnimation));	//##(2)将故障动画数据更新到显示缓存    
    regs.flags.AnimEn = 1;                              //##(2)重新使能动画显示
    enable_interrupts(INT_TIMER3);                      //##(2)恢复中断
	retry = 0u;
	while(regs.flags.AnimEn && retry<200) {		//##(2)等待播放动画完成
            delay_ms(10);
            retry++;
	}
}

/*###############################################################################################################################
# 函数名 :  void microcontroller_sleep(void)                                                                                    #
# 功  能 :  微控制器睡眠                                                                                                        #
# 参  数 :  NONE                                                                                                                #
# 说  明 :  NONE                                                                                                                #
###############################################################################################################################*/
void PowerStatusDisplay(boolean powerState) {
    uint8_t retry;
//##(0)执行显示    
    OnOff_StatusDisplay(powerState);                //##(0)脱离设备则进入睡眠(执行关机显示)
//##(0)等待显示完成
    while(regs.flags.AnimEn && retry<200) {         //##(0)每次开机/关机必须播放完动画才能到下一步 
        delay_ms(10); retry++;                      //##(0)
    } 
//##(0)使能显示标志清零
    regs.flags.AnimEn = false;                      //##(0)禁止显示 
}

/*###############################################################################################################################
#  应用声明结束                                                                                                                 #
###############################################################################################################################*/
#ifdef	__cplusplus
}
#endif
#endif

 